# Keil uVision project project.uvprojx, settings and files
target rtthread-frdm-mcxa156 (6220000::V6.22::ARMCLANG)
  device: MCXA156VLL NXP
  pack: NXP.MCXA156_DFP.25.06.00
  cpu: IRAM(0x20000000,0x01e000) IRAM2(0x04000000,0x3000) IROM(0x03000000,0x2000) IROM2(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: __RTTHREAD__, __STDC_LIMIT_MACROS, DEBUG, RT_USING_LIBC, RT_USING_ARMLIBC, CPU_MCXA156VLL, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --target=arm-arm-none-eabi
  c include: packages\nxp-mcx-cmsis-latest\Core\Include;..\..\..\..\..\components\drivers\include;..\Libraries\drivers\config;..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\include;..\..\..\..\..\components\drivers\include;.;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\compilers\common\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\smp_call;..\..\..\..\..\components\libc\compilers\common\extension;packages\nxp-mcx-series-latest\MCXA156\middleware\sdmmc\inc;..\..\..\..\..\components\libc\posix\ipc;board\ports;packages\nxp-mcx-series-latest\MCXA156\drivers;..\Libraries\drivers;board\MCUX_Config\board;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\..\components\drivers\include;packages\nxp-mcx-series-latest\MCXA156\components\codec;..\..\..\..\..\components\drivers\phy;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\utilities\ulog;..\..\..\..\..\components\libc\posix\io\poll;..\..\..\..\..\components\libc\posix\io\epoll;board;applications;..\..\..\..\..\components\drivers\include;packages\nxp-mcx-series-latest\MCXA156;..\..\..\..\..\libcpu\arm\cortex-m33;..\..\..\..\..\components\drivers\include;packages\nxp-mcx-series-latest\MCXA156\middleware\sdmmc\port;..\..\..\..\..\components\finsh;..\..\..\..\..\components\libc\posix\io\eventfd
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1e000
  memory RVCT10: RAM 0x4000000 size 0x3000
  scatter file: .\board\linker_scripts\MCXA156_flash.scf
  group Applications
    applications/: main.c
    ./applications/: adc_app.c dht11_app.c drv_dht11.c drv_mq2.c MQ2_app.c uart_app.c ATGM336H_app.c esp_app.c drv_max30102.c max30102_app_v2.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/hwtimer/: hwtimer.c
    ../../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/misc/: adc.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    board/ports/: drv_spi_sample_rw007.c
    ../Libraries/drivers/: drv_adc.c drv_i2c.c drv_pin.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: msh_parse.c cmd.c msh.c shell.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../../src/klibc/: kstring.c rt_vsscanf.c rt_vsnprintf_std.c kstdio.c kerrno.c
  group libcpu
    ../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    packages/nxp-mcx-series-latest/MCXA156/arm/: startup_MCXA156.s
    packages/nxp-mcx-series-latest/MCXA156/drivers/: fsl_aoi.c fsl_clock.c fsl_cmc.c fsl_common.c fsl_common_arm.c fsl_crc.c fsl_ctimer.c fsl_edma.c fsl_edma_soc.c fsl_eim.c fsl_eqdc.c fsl_erm.c fsl_freqme.c fsl_glikey.c fsl_gpio.c fsl_i3c.c fsl_i3c_edma.c fsl_inputmux.c fsl_lpadc.c fsl_lpcmp.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lptmr.c fsl_lpuart.c fsl_lpuart_edma.c fsl_ostimer.c fsl_pwm.c fsl_reset.c fsl_spc.c fsl_utick.c fsl_vbat.c fsl_waketimer.c fsl_wuu.c fsl_wwdt.c
    packages/nxp-mcx-series-latest/MCXA156/: system_MCXA156.c
  group Utilities
    ../../../../../components/utilities/ulog/: ulog.c
    ../../../../../components/utilities/ulog/backend/: console_be.c
